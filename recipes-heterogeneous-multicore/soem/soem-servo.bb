# Copyright 2025 NXP

require recipes-heterogeneous-multicore/includes/hmc-example.inc

HMC_EXAMPLE_NAME = "soem_servo"

RTOS_INDUSTRIAL_BOARD:imx95-15x15-lpddr4x-evk = "imx95lp4xevk15"
