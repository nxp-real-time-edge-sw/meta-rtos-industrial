# Copyright 2026 NXP

require recipes-heterogeneous-multicore/includes/hmc-example.inc

HMC_EXAMPLE_NAME = "driver_examples"
