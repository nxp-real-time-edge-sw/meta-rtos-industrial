# Copyright 2025 NXP

require recipes-heterogeneous-multicore/includes/hmc-example.inc

HMC_EXAMPLE_NAME = "hello_world"
