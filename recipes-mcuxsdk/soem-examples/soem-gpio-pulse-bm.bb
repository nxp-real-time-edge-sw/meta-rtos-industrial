# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "soem_gpio_pulse_bm"
MCUXSDK_EXAMPLE_DIR = "examples/soem_examples/soem_gpio_pulse/bm"
