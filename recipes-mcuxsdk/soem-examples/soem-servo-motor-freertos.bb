# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "soem_servo_motor_freertos"
MCUXSDK_EXAMPLE_DIR = "examples/soem_examples/soem_servo_motor/freertos"
