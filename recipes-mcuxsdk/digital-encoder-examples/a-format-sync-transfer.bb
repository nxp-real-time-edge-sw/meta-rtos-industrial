# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "a-format_sync_transfer"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/a-format/sync_transfer"

MCUXSDK_CORE_IDS:mx943-nxp-bsp = "cm33_core1"
