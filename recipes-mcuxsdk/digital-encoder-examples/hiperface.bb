# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "hiperface"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/hiperface"
