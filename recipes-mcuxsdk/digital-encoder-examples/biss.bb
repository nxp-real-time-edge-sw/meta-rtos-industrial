# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "biss"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/biss"
