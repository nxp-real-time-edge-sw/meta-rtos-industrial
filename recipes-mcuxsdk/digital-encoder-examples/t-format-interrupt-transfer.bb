# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "t-format_interrupt_transfer"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/t-format/interrupt_transfer"
