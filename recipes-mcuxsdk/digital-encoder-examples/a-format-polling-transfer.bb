# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "a-format_polling_transfer"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/a-format/polling_transfer"
