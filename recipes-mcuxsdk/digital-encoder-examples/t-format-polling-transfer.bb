# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "t-format_polling_transfer"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/t-format/polling_transfer"
