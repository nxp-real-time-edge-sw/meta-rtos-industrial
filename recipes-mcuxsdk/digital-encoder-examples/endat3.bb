# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "endat3"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/endat3"
