# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "endat2p2"
MCUXSDK_EXAMPLE_DIR = "examples/digital_encoder_examples/endat2p2"
