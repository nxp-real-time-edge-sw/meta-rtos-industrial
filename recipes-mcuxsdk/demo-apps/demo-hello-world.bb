# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "hello_world"
MCUXSDK_EXAMPLE_DIR = "examples/demo_apps/hello_world"
