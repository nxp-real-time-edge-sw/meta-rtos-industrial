# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "iuart_9bit_interrupt_transfer"
MCUXSDK_EXAMPLE_DIR = "examples/driver_examples/iuart/9bit_interrupt_transfer"
