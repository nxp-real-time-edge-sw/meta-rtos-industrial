# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "igpio_led_output"
MCUXSDK_EXAMPLE_DIR = "examples/driver_examples/igpio/led_output"
