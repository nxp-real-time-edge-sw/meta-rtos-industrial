# Copyright 2026 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "hsr_switch"
MCUXSDK_EXAMPLE_DIR = "examples/driver_examples/netc/hsr_switch"
