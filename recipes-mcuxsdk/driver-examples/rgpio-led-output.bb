# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "rgpio_led_output"
MCUXSDK_EXAMPLE_DIR = "examples/driver_examples/rgpio/led_output"
