# Copyright 2026 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "co_manager_bm"
MCUXSDK_EXAMPLE_DIR = "examples/canopennode_examples/manager/bm"

MCUXSDK_CORE_IDS:mx943-nxp-bsp = "cm33_core1"
