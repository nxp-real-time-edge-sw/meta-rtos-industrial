# Copyright 2026 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "co_device_bm"
MCUXSDK_EXAMPLE_DIR = "examples/canopennode_examples/device/bm"

MCUXSDK_CORE_IDS:mx943-nxp-bsp = "cm33_core1"
