# Copyright 2025 NXP

require recipes-mcuxsdk/includes/mcuxsdk-example.inc

MCUXSDK_EXAMPLE_NAME = "freertos_hello"
MCUXSDK_EXAMPLE_DIR = "examples/freertos_examples/freertos_hello"
